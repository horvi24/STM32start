<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\G071RB_TIM1_ICsetup.ewp</path>
  </project>
  <batchBuild />
</workspace>
